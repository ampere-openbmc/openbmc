FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
             file://0001-meta-ampere-Fix-compilation-error-for-uboot-in-styhead.patch \
           "

