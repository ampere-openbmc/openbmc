PACKAGECONFIG:remove = " intrusionsensor"
