EXTRA_OEMESON:append = " -Dsync-down-hwclock=true"
