FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

PACKAGECONFIG = "   \
    adcsensor       \
    fansensor       \
    hwmontempsensor \
    ipmbsensor      \
    external        \
    "

