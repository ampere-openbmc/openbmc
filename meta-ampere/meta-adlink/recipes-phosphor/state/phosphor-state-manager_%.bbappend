FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	      file://0001-Limit-power-actions-when-the-host-is-off.patch \
	   "

