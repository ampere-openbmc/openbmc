FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

PACKAGECONFIG += " ac01-nvparm"
