SRC_URI = " \
           git://github.com/ampere-openbmc/linux;protocol=https;branch=ampere \
           file://defconfig \
          "

SRCREV="cbc8f398f82d516284db5442da4c78749cdf2cb8"
