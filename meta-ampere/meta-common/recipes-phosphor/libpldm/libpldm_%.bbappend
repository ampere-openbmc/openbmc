FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
PACKAGECONFIG = "abi-development"
