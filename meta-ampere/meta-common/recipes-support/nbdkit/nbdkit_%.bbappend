PACKAGECONFIG = ""
PACKAGECONFIG[curl] = "--with-curl,--without-curl,curl"
